# Repository zacharesmer/imac_g3_ivad_board_init

## KiCad design schematics_and_pcbs/imac_g3_slot_loading_J22_adapter_board/imac_g3_slot_loading_J22_adapter_board.kicad_pcb

Parts:
C1: 1uF; CP_Radial_D5.0mm_P2.00mm; Part# 399-6596-ND
H1: MountingHole_Pad; MountingHole_3.5mm_Pad
J1: Conn_02x13_Odd_Even; PinHeader_2x13_P2.54mm_Vertical; Part# 609-3240-ND
J2: Screw_Terminal_01x10; TerminalBlock_Phoenix_PT-1,5-10-5.0-H_1x10_P5.00mm_Horizont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; Part# 277-9080-ND
J3: AudioJack3; Jack_3.5mm_CUI_SJ1-3533NG_Horizontal_CircularHoles; Part# CP1-3533NG-ND
J4: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical; Part# 609-3234-ND
JP1, JP3: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R2: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal; Part# CF14JT220RCT-ND
R3: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal; Part# CF14JT2K20CT-ND

Connections:
/+AC: J1.24, J1.26, J2.1
/+AMBER_LED: J1.20, R2.2
/+GREEN_LED: J1.19, JP3.1 (A), R1.2
/+LEFT_SPEAKER: J1.14, J2.8
/+MICROPHONE: J1.3, JP2.2 (C)
/+RIGHT_SPEAKER: J1.13, J2.10
/-AC: J1.23, J1.25, J2.2
/-LEFT_SPEAKER: J1.16, J2.7
/-RIGHT_SPEAKER: J1.15, J2.9
/HEADPHONE_1_LEFT: J1.10, J4.6
/HEADPHONE_1_RIGHT: J1.9, J4.5
/HEADPHONE_1_SENSE: J1.8, J4.4
/HEADPHONE_2_LEFT: J1.6, J4.2
/HEADPHONE_2_RIGHT: J1.5, J4.1
/HEADPHONE_2_SENSE: J1.7, J4.3
/MICROPHONE_POWER: J3.R, JP3.2 (B), R3.2
/POWER_BUTTON: J1.17, J2.4
GNDREF: H1.1, J1.1, J1.2, J1.4, J1.11, J1.18, J2.6, J3.S
unnamed: J2.3, R1.1
unnamed: J2.5, R2.1
unnamed: JP1.1 (A), R3.1
unnamed: C1.2, JP1.2 (B), JP2.1 (A)
unnamed: C1.1, J3.T, JP2.3 (B)

Notes on the sheet:
This circuit is to be able to use an electret microphone that does contain a circuit in the package. To use the circuit solder JP1 and solder pads 1 and 2 of JP2. To connect directly to the mic from the computer, solder pads 2 and 3 on JP2 and leave JP1 unsoldered JP3 is for testing 5V in the circu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

Board: 2 copper layers, 65.0 x 30.0 mm, 12 parts (4 on the bottom side), 23 nets.

## Commit log

2026-03-30 Use an in-stock capacitor in J22 board
    Also add the regenerated gerbers
2026-03-30 Update bill of materials
    - Use a different capacitor that is still manufactured
    - Swap the expensive 3M header for a cheaper amphenol
2026-03-30 make bill of materials format match
2026-03-30 swap out obsolete crystal
2026-03-30 remove old kicad project
2026-03-30 update capacitor
2026-03-30 update crystal
2026-04-12 Add init recording to arduino code
    Add an init sequence recorded from my mac
    Also change the display adjustment key bindings to be a
    little easier to use from minicom.
    Fix an overflow when changing the settings (maxing out settings
    was wrapping around to the minimum value)
2026-04-14 Adjust the keyboard layout for adjusting settings
    Also make "p" actually print current settings, instead of the original
    default ones.
    And add a help message to print which letters change which settings.
2026-04-14 add basic how to guide
